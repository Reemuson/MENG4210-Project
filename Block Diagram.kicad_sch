File: Block Diagram.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: feat: checked REV A
Other:
- note removed: "+??V"
- note removed: "+A3V3"
